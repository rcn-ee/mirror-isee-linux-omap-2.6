## drivers/staging/omap3-sgx/Kconfig
```kconfig
config OMAP3_SGX
	bool "OMAP3 SGX support (TI: 3.01.00.06)"
	depends on OMAP2_DSS && m
	help
	  This is TI's OMAP3 SGX Kernel Modules 3.01.00.06
```
